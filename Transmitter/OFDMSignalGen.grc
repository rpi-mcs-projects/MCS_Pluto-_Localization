options:
  parameters:
    generate_options: qt_gui
    id: OFDMSignalGen
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: LO_freq
  id: variable
  parameters:
    value: '1560000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jpizz/Downloads/MCS_Final_Project/custom_ofdm_signal.bin
    repeat: 'True'
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: LO_freq
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}

connections:
- [blocks_file_source_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
